<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CUITBIKE_V12_MSP430-SV10_161201_D.ewp</path>
  </project>
  <batchBuild/>
</workspace>


