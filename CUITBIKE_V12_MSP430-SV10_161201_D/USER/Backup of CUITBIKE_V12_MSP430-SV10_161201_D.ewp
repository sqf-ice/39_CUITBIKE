# IAR project Backup of CUITBIKE_V12_MSP430-SV10_161201_D.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlmff.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 1024
  General.GHeapSize2: 128
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\HARDWARE\AD7414; ..\HARDWARE\AT24C512; ..\HARDWARE\LTC1865L; ..\HARDWARE\WDOG; ..\HARDWARE\OLED; ..\HARDWARE\JLX12864; ..\SYSTEM\ADC12; ..\SYSTEM\CHECK; ..\SYSTEM\DELAY; ..\SYSTEM\FFT; ..\SYSTEM\GPIO; ..\SYSTEM\SYSCLK; ..\SYSTEM\TIMER; ..\SYSTEM\USART; ..\USER
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group HARDWARE/AT24C512
    ../HARDWARE/AT24C512/: eeprom.c eeprom.h
  group HARDWARE/JLX12864
    ../HARDWARE/JLX12864/: LCD12864.c LCD12864.h PIX.h
  group HARDWARE/WDOG
    ../HARDWARE/WDOG/: wdog.c wdog.h
  group SYSTEM/ADC12
    ../SYSTEM/ADC12/: adc12.c adc12.h
  group SYSTEM/check
    ../SYSTEM/CHECK/: check.c check.h
  group SYSTEM/DELAY
    ../SYSTEM/DELAY/: delay.h
  group SYSTEM/FFT
    ../SYSTEM/FFT/: fft.c fft.h
  group SYSTEM/GPIO
    ../SYSTEM/GPIO/: GPIO.c GPIO.h
  group SYSTEM/SYSCLK
    ../SYSTEM/SYSCLK/: sysclk.c sysclk.h
  group SYSTEM/TIMER
    ../SYSTEM/TIMER/: timer.c timer.h
  group USER
    ./: includes.h main.c
